# Keil uVision project weather_station.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: weather_station +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\hardware\setphone;..\hardware\flash;..\hardware\huanjing;..\hardware\sendmessage;..\hardware\touch_main;..\main;..\system\bin;..\system\delay;..\system\iic;..\system\interrupt;..\system\stc;..\tft_touch_sd\font;..\tft_touch_sd\touch;..\tft_touch_sd\tft;..\tft_touch_sd\txt;..\hardware\chuankou;..\hardware\zhuce;..\hardware\init
  group main
    ../main/: main.c
  group system
    ../system/bin/: bin.c
    ../system/delay/: delay.c
    ../system/iic/: iic.c
    ../system/interrupt/: interrupt.c
  group hardware
    ../hardware/flash/: flash.c
    ../hardware/huanjing/: huanjing.c
    ../hardware/touch_main/: touch_main.c
    ../hardware/chuankou/: chuankou.c
    ../hardware/setphone/: setphone.c
    ../hardware/sendmessage/: sendmessage.c
    ../hardware/zhuce/: zhuce.c
    ../hardware/init/: init.c
  group tft_touch
    ../tft_touch_sd/font/: font.c fontcheck.c
    ../tft_touch_sd/tft/: tft.C
    ../tft_touch_sd/touch/: touch.c
    ../tft_touch_sd/txt/: txt.c
